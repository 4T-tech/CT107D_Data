# Keil uVision project IAP15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IAP15
  c flags: Optimize=8 SizeSpeed=1
  c define: PCF8591
  c include: ..\Driver
  group Source Group 1
    ./: main.c tim.c
    ../Driver/: seg.c ds1302.c ds18b20.c i2c.c
    ./: key.c
